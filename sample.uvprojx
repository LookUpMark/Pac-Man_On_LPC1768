# Keil uVision project sample.uvprojx, settings and files
target LandTiger_LPC1768 (release) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=2 v6Lang=5 v6LangP=3
  c include: .\Source;.\Source\button_EXINT;.\Source\GLCD;.\Source\CAN;.\Source\timer;.\Source\TouchPanel;.\Source\CMSIS_core
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./Source/: startup_LPC17xx.s
  group main
    ./Source/: sample.c
    ./: functions.h blinky.c game.c pacman.c
  group button_EXINT
    ./Source/button_EXINT/: IRQ_button.c lib_button.c button.h
  group timer
    ./Source/timer/: IRQ_timer.c timer.h lib_timer.c
  group joystick
    ./Source/joystick/: joystick.h lib_joystick.c
  group RIT
    ./Source/RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group music
    ./Source/music/: music.h music.c
  group ADC
    ./Source/ADC/: adc.h IRQ_adc.c lib_adc.c
  group GLCD
    ./Source/GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group TP
    ./Source/TouchPanel/: TouchPanel.c TouchPanel.h
  group CAN
    ./Source/CAN/: IRQ_CAN.c lib_CAN.c CAN.h
  group lib_SoC_board
    ./Source/: system_LPC17xx.c
  group CMSIS_core
    ./Source/CMSIS_core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
  group led
    ./Source/led/: funct_led.c led.h lib_led.c
target SW_Debug (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: sample
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c define: SIMULATOR
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 6.1.0
